# Keil uVision project project_demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project_demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PLATFORM_STM32F103X PROJECT_DEMO
  c include: ..\..\device;..\..\platform\core\arm\cm3;..\..\platform\stm32\stm32f103c8t6\stm32f1xx_ll\inc\Legacy;..\..\platform\stm32\stm32f103c8t6\stm32f1xx_ll\inc;..\..\platform\stm32\stm32f103c8t6\stm32f1xx_ll;..\..\platform\stm32\stm32f103c8t6;..\..\platform\drivers;..\..\platform;..\..\common\fifo;..\..\os
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\project_demo.sct
  group APP
    ../../app/: main.c
  group DEVICE
    ../../device/: led.c
  group COMMON
    ../../common/fifo/: fifo.c
  group DRIVERS
    ../../platform/drivers/: drv_adc.c drv_gpio.c drv_i2c.c drv_spi.c drv_timer.c drv_uart.c bsp.c drv_platform.c
  group PLATFORM
    ../../platform/stm32/stm32f103c8t6/: adc_stm32f1xx.c gpio_stm32f1xx.c i2c_stm32f1xx.c uart_stm32f1xx.c platform_stm32f1xx.c
  group STM32F1XX_LL
    ../../platform/stm32/stm32f103c8t6/stm32f1xx_ll/src/: stm32f1xx_ll_adc.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c system_stm32f1xx.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c
  group MDK/ARM
    ../../platform/stm32/stm32f103c8t6/stm32f1xx_ll/startup/: startup_stm32f103xb.s
software components: CMSIS:CORE 5.4.0
